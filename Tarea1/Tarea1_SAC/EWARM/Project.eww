<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tarea1_SAC.ewp</path>
  </project>
  <batchBuild />
</workspace>
